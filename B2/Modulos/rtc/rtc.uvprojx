# Keil uVision project rtc.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RTC
  c flags: Optim=2 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HSE_VALUE=8000000
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c rtc.c rtc.h
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0, Network:CORE 7.19.0, Network:Interface:ETH 7.19.0, Network:Service:SNTP Client 7.19.0, Network:Service:Web Server Compact 7.19.0, Network:Socket:TCP 7.19.0, Network:Socket:UDP 7.19.0, CMSIS Driver:Ethernet MAC 2.10, CMSIS Driver:Ethernet PHY:LAN8742A 1.3.0, Device:STM32Cube Framework:Classic 1.8.1, Device:STM32Cube HAL:Common 1.8.1, Device:STM32Cube HAL:Cortex 1.8.1, Device:STM32Cube HAL:DMA 1.8.1, Device:STM32Cube HAL:GPIO 1.8.1, Device:STM32Cube HAL:PWR 1.8.1, Device:STM32Cube HAL:RCC 1.8.1, Device:STM32Cube HAL:RTC 1.8.1, Device:STM32Cube HAL:SPI 1.8.1, Device:STM32Cube HAL:SRAM 1.8.1, Device:STM32Cube HAL:TIM 1.8.1, Device:Startup 2.6.3
