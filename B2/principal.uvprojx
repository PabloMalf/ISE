# Keil uVision project principal.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lcd
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: HSE_VALUE=8000000
  c include: .\Modulos\buz;.\Modulos\cam;.\Modulos\key;.\Modulos\irq;.\Modulos\lcd;.\Modulos\nfc;.\Modulos\rgb;.\Modulos\rtc;.\Modulos\srv;.\Modulos\ttf
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c principal.c
  group Modulos
    ./Modulos/buz/: buz.c
    ./Modulos/cam/: cam.c
    ./Modulos/key/: key.c
    ./Modulos/irq/: irq.c
    ./Modulos/lcd/: lcd.c
    ./Modulos/nfc/: nfc.c
    ./Modulos/rgb/: rgb.c
    ./Modulos/rtc/: rtc.c
    ./Modulos/srv/: srv.c
    ./Modulos/ttf/: ttf.c
software components: CMSIS-Compiler:CORE 1.0.0, CMSIS:CORE 5.5.0, CMSIS:RTOS2:Keil RTX5 5.5.3, Compiler:Event Recorder 1.4.0, File System:CORE 6.16.6, File System:Drive:Memory Card 6.16.6, Network:CORE 7.19.0, Network:Interface:ETH 7.19.0, Network:Service:SNTP Client 7.19.0, Network:Service:Web Server Compact 7.19.0, Network:Socket:TCP 7.19.0, Network:Socket:UDP 7.19.0, CMSIS Driver:Ethernet MAC 2.9, CMSIS Driver:Ethernet PHY:LAN8742A 1.3.0, CMSIS Driver:I2C 2.10, CMSIS Driver:SPI 2.15, CMSIS-Compiler:File Interface:MDK-MW File System 1.0.0, Device:STM32Cube Framework:Classic 1.7.9, Device:STM32Cube HAL:Common 1.7.9, Device:STM32Cube HAL:Cortex 1.7.9, Device:STM32Cube HAL:DCMI 1.7.9, Device:STM32Cube HAL:DMA 1.7.9, Device:STM32Cube HAL:GPIO 1.7.9, Device:STM32Cube HAL:I2C 1.7.9, Device:STM32Cube HAL:PWR 1.7.9, Device:STM32Cube HAL:RCC 1.7.9, Device:STM32Cube HAL:RTC 1.7.9, Device:STM32Cube HAL:SPI 1.7.9, Device:STM32Cube HAL:TIM 1.7.9, Device:Startup 2.6.3
